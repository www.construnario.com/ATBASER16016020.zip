Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition[CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: C:\Users\Usuario\Desktop\JOMBAR\MUESTRAS B.I.M\IFC\ATLAS\NIVEL 01\ATBASER16016020.ifc
Time: 2017-02-22T20:17:13
Written by: ACCA_IFC.dll Version 200
Made in: Edificius 8.00c

# IfcSite, Default Site
RefLatitude: 0, 0, 0; RefLongitude: 0, 0, 0; RefElevation: 0 mm

# IfcBuildingStorey (4)
In: Default Building
Name | Elevation (mm) | NominalHeight (mm)
TERRENO | -1500 | 1000
Cimentación | -500 | 500
Planta Baja | 0 | 3200
Cubierta | 3200 | 0

# IfcFurnishingElement: CALZO ATLAS 01, CALZO BASE ATLAS 01
In: Planta Baja
Description: CALZO BASE ATLAS 01 ROSCAS; Material: Color_01
Pset_ManufacturerTypeInformation - ArticleNumber: CALZO BASE ATLAS 01 16016020; ModelReference: ATBASER16016020; ModelLabel: ATBASER16016020; Manufacturer: JOMBAR; ProductionYear: 2017
PROPIDADES GENERALES - COMPOSICIÓN: COMPOSITE POLIETILENO; COLOR: NEGRO; PESO POR UNIDAD: 181 g; TEMPERATURA MÁXIMA ALMACENAMIENTO: 60º C; CARGA MÁXIMA POR cm2: >100 Kg; RESISTENCIA A LA COMPRESIÓN: >100 MPa
